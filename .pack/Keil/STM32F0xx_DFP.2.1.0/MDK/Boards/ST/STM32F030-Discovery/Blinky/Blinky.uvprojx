# Keil uVision project Blinky.uvprojx, settings and files
target Debug (6140000::V6.14::ARMCLANG)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0-dev16
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT6: RAM 0x20001b00 size 0x500
  memory RVCT9: RAM 0x20000000 size 0x1b00
  group Source
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F030R8Tx/STCubeGenerated/Src/: main.c stm32f0xx_it.c
    ./RTE/Device/STM32F030R8Tx/STCubeGenerated/Inc/: stm32f0xx_it.h
target Release (6140000::V6.14::ARMCLANG)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0-dev16
  cpu: as above
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1b00
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Device:STM32Cube HAL 1.11.0, Board Support:Buttons 1.1.0, Board Support:LED 1.1.0
