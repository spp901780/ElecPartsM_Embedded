# Keil uVision project HID.uvprojx, settings and files
target Debug (6140000::V6.14::ARMCLANG)
  device: STM32F072VBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0-dev16
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HID
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x20003800 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x3800
  group Source
    ./: HID.c USBD_User_HID_0.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F072VBTx/STCubeGenerated/Src/: main.c stm32f0xx_it.c
    ./RTE/Device/STM32F072VBTx/STCubeGenerated/Inc/: stm32f0xx_it.h
target Release (6140000::V6.14::ARMCLANG)
  device: STM32F072VBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0-dev16
  cpu: as above
  output: HID
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3800
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, USB:CORE 6.14.0, USB:CORE 6.14.0, USB:Device 6.14.0, USB:Device:HID 6.14.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube HAL 1.11.0, CMSIS Driver:USB Device 1.2.0
