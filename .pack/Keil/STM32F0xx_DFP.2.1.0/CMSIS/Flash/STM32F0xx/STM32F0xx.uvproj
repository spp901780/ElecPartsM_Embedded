# Keil uVision project STM32F0xx.uvproj, settings and files
target STM32F0xx_16 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F0xx_16
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F0xx_16
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32F0xx_32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F0xx_32
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F0xx_32
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F0xx_64 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F0xx_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F0xx_64
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F0xx_64_2K (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F0xx_64_2K
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F0xx_64_2K
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F0xx_128_2K (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F0xx_128_2K
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F0xx_128_2K
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F0xx_256_2K (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F0xx_256_2K
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F0xx_256_2K
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F05xx_OPT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F0xx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: FLASH_OPT
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
